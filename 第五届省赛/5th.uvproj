# Keil uVision project 5th.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 5th +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c module.c ds1302.c dig.c timer.c iic.c key.c
